# Keil uVision project DRIVER.uvproj, settings and files
target DRIVER (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32 DRIVER +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: .\STARTUP;.\STD;.\APP;.\BSP;.\DRIVER\Collectdata;.\DRIVER\Global;.\DRIVER\PID;.\FUN;.\FWLIB\inc;.\FWLIB\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./STARTUP/: startup_stm32f10x_hd.s
  group STD
    ./STD/: MAKEFILE.h STD.h TypeAndMacro.h
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
  group APP
    ./APP/: APP.c
  group BSP
    ./BSP/: BSP.c BSP.h Hard_ware.c Hard_ware.h
  group FUN
    ./FUN/: CAN.c CAN.h LCD.c LCD.h LED.c LED.h queue.c queue.h Ele.c Ele.h USART.c USART.h
  group DRIVER
    ./DRIVER/Collectdata/: Collectdata.c Collectdata.h
    ./DRIVER/Global/: global.c global.h
    ./DRIVER/PID/: Motor__Control.c Motor__Control.h PID.c PID.h
